FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://platform-top.h \
            file://user_2018-09-24-12-03-00.cfg \
            file://user_2018-09-24-13-15-00.cfg \
            "
