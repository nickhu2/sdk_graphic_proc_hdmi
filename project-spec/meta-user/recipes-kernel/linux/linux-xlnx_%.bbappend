SRC_URI += "file://user_2018-09-24-14-23-00.cfg \
            file://user_2018-09-24-15-21-00.cfg \
            file://user_2018-09-28-09-19-00.cfg \
            file://user_2018-09-29-00-36-00.cfg \
            file://user_2018-09-29-01-08-00.cfg \
            file://user_2018-09-29-01-21-00.cfg \
            file://user_2018-09-29-02-01-00.cfg \
            file://user_2018-09-29-02-09-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

